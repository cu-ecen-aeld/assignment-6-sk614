FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://disable-md-faulty.cfg"
